# Keil uVision project project.uvprojx, settings and files
target rt-thread (6240000::V6.24::ARMCLANG)
  device: STM32H7S7L8Hx STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5
  c define: STM32H7S7xx, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, RT_USING_ARMLIBC, USE_HAL_DRIVER, __RTTHREAD__
  c include: rt-thread\components\dfs\dfs_v1\include;packages\CherryUSB-latest\class\vendor\display;packages\CherryUSB-latest\common;packages\CherryUSB-latest\class\hid;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\epoll;packages\CherryUSB-latest\class\video;libraries\CMSIS\Include;packages\CherryUSB-latest\class\mtp;rt-thread\components\drivers\include;rt-thread\components\drivers\include;libraries\drivers;packages\CherryUSB-latest\class\wireless;libraries\drivers\include\config;libraries\STM32H7RSxx_HAL_Driver\Inc;board\CubeMX_Config\Appli\Core\Inc;rt-thread\libcpu\arm\common;packages\CherryUSB-latest\class\vendor\wifi;applications;packages\CherryUSB-latest\class\hub;rt-thread\components\drivers\include;packages\CherryUSB-latest\core;libraries\bsp_components;board\port;rt-thread\components\libc\compilers\common\extension;rt-thread\include;packages\CherryUSB-latest\class\midi;rt-thread\components\drivers\include;libraries\CMSIS\Device\ST\STM32H7RSxx\Include;libraries\drivers\include;rt-thread\components\finsh;packages\CherryUSB-latest\class\dfu;rt-thread\components\libc\compilers\common\extension\fcntl\octal;.;rt-thread\components\libc\posix\ipc;rt-thread\components\dfs\dfs_v1\filesystems\romfs;packages\CherryUSB-latest\class\audio;packages\CherryUSB-latest\osal;rt-thread\components\libc\posix\io\poll;packages\CherryUSB-latest\class\msc;rt-thread\components\libc\posix\io\eventfd;packages\CherryUSB-latest;packages\CherryUSB-latest\class\cdc;board;rt-thread\components\libc\compilers\common\include;rt-thread\components\dfs\dfs_v1\filesystems\elmfat;rt-thread\libcpu\arm\cortex-m7;packages\CherryUSB-latest\class\vendor\xbox;rt-thread\components\dfs\dfs_v1\filesystems\devfs;packages\CherryUSB-latest\class\serial;packages\CherryUSB-latest\class\adb;packages\CherryUSB-latest\class\vendor\net
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CherryUSB
    packages/CherryUSB-latest/class/video/: usbd_video.c
    packages/CherryUSB-latest/class/vendor/display/: usbd_display.c
    packages/CherryUSB-latest/demo/: cdc_acm_template.c
    packages/CherryUSB-latest/class/audio/: usbd_audio.c
    packages/CherryUSB-latest/class/cdc/: usbd_cdc_acm.c
    packages/CherryUSB-latest/osal/: usb_osal_rtthread.c
    packages/CherryUSB-latest/port/dwc2/: usb_glue_st.c usb_dc_dwc2.c
    packages/CherryUSB-latest/platform/rtthread/: rt_usb_msh.c rt_usbd_serial.c rt_usbd_adb_msh.c rt_usb_check.c rt_usbd_msc.c
    packages/CherryUSB-latest/class/dfu/: usbd_dfu.c
    packages/CherryUSB-latest/class/msc/: usbd_msc.c
    packages/CherryUSB-latest/core/: usbd_core.c
    packages/CherryUSB-latest/class/hid/: usbd_hid.c
    packages/CherryUSB-latest/class/adb/: usbd_adb.c
    ./packages/CherryUSB-latest/demo/: adb_template.c
    ./packages/CherryUSB-latest/platform/rtthread/: rt_vfs_dfs.c
    ./packages/CherryUSB-latest/class/adb/: usbd_adb_sync.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    rt-thread/components/drivers/serial/: dev_serial.c
  group Drivers
    board/CubeMX_Config/Appli/Core/Src/: stm32h7rsxx_hal_msp.c
    board/: board.c drv_mpu.c
    board/port/: filesystem.c
    libraries/drivers/: drv_common.c drv_gpio.c drv_psram.c drv_sdmmc.c drv_spi.c drv_usart.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/dfs_v1/filesystems/romfs/: dfs_romfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: msh_parse.c msh.c msh_file.c shell.c cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    rt-thread/libcpu/arm/common/: div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group STM32_HAL
    libraries/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/arm/: startup_stm32h7r7xx.s
    libraries/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_cec.c stm32h7rsxx_hal_rng.c stm32h7rsxx_hal_sram.c stm32h7rsxx_ll_sdmmc.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_cryp.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_xspi.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_crc.c stm32h7rsxx_hal_adc.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_adc_ex.c stm32h7rsxx_hal_sd.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_crc_ex.c stm32h7rsxx_hal_cryp_ex.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_usart.c
    libraries/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/: system_stm32h7rsxx.c
