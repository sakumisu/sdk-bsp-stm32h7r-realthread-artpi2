# Keil uVision project template.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H7R7L8HxH STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: IRAM(0x00000000,0x00010000) IRAM2(0x20000000,0x00010000) IROM(0x08000000,0x00010000) XRAM(0x24000000,0x00072000) XRAM2(0x30000000,0x00008000) XRAM3(0x38800000,0x00001000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT6: RAM 0x24000000 size 0x72000
  memory RVCT7: RAM 0x30000000 size 0x8000
  memory RVCT8: RAM 0x38800000 size 0x1000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
