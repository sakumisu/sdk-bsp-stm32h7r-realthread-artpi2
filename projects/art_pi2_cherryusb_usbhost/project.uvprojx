# Keil uVision project project.uvprojx, settings and files
target rt-thread (6240000::V6.24::ARMCLANG)
  device: STM32H7S7L8Hx STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=6 v6LangP=8
  c define: USE_HAL_DRIVER, __STDC_LIMIT_MACROS, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, STM32H7S7xx, RT_USING_ARMLIBC, __RTTHREAD__
  c include: board;packages\CherryUSB-latest\class\serial;rt-thread\include;rt-thread\components\dfs\dfs_v1\include;packages\CherryUSB-latest\class\vendor\xbox;libraries\bsp_components;packages\CherryUSB-latest\class\msc;libraries\drivers;rt-thread\components\net\lwip\port;packages\CherryUSB-latest\class\vendor\net;rt-thread\components\drivers\include;libraries\drivers\include\config;packages\CherryUSB-latest\class\hub;rt-thread\components\net\lwip\lwip-2.1.2\src\include;rt-thread\components\libc\posix\ipc;board\port;rt-thread\components\libc\compilers\common\extension;packages\CherryUSB-latest\class\hid;rt-thread\components\drivers\include;packages\CherryUSB-latest\class\audio;rt-thread\components\finsh;rt-thread\components\libc\posix\io\epoll;rt-thread\components\libc\posix\io\eventfd;packages\CherryUSB-latest\class\video;rt-thread\libcpu\arm\common;rt-thread\components\dfs\dfs_v1\filesystems\devfs;packages\CherryUSB-latest\class\vendor\wifi;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\include;.;libraries\drivers\include;rt-thread\components\libc\compilers\common\extension\fcntl\octal;packages\CherryUSB-latest\common;rt-thread\components\dfs\dfs_v1\filesystems\elmfat;packages\CherryUSB-latest\core;packages\CherryUSB-latest\class\dfu;packages\CherryUSB-latest\class\adb;applications;rt-thread\components\net\lwip\lwip-2.1.2\src\include\compat\posix;libraries\CMSIS\Include;libraries\CMSIS\Device\ST\STM32H7RSxx\Include;board\CubeMX_Config\Appli\Core\Inc;rt-thread\libcpu\arm\cortex-m7;packages\CherryUSB-latest\class\cdc;rt-thread\components\drivers\include;rt-thread\components\net\lwip\lwip-2.1.2\src\include\netif;packages\CherryUSB-latest\class\wireless;packages\CherryUSB-latest;packages\CherryUSB-latest\class\vendor\display;libraries\STM32H7RSxx_HAL_Driver\Inc;packages\CherryUSB-latest\class\midi;rt-thread\components\libc\posix\io\poll
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CherryUSB
    packages/CherryUSB-latest/core/: usbh_core.c
    packages/CherryUSB-latest/class/vendor/net/: usbh_rtl8152.c usbh_asix.c
    packages/CherryUSB-latest/platform/rtthread/: rt_usbh_msc.c rt_usbh_serial.c rt_usbh_lwip.c rt_usb_check.c rt_usb_msh.c
    packages/CherryUSB-latest/class/serial/: usbh_cdc_acm.c usbh_serial.c usbh_pl2303.c usbh_ftdi.c usbh_ch34x.c usbh_cp210x.c
    packages/CherryUSB-latest/class/video/: usbh_video.c
    packages/CherryUSB-latest/port/dwc2/: usb_glue_st.c usb_hc_dwc2.c
    packages/CherryUSB-latest/class/hub/: usbh_hub.c
    packages/CherryUSB-latest/class/cdc/: usbh_cdc_ecm.c usbh_cdc_ncm.c
    packages/CherryUSB-latest/osal/: usb_osal_rtthread.c
    packages/CherryUSB-latest/class/msc/: usbh_msc.c
    packages/CherryUSB-latest/class/wireless/: usbh_rndis.c
    packages/CherryUSB-latest/class/hid/: usbh_hid.c
    packages/CherryUSB-latest/class/audio/: usbh_audio.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/serial/: dev_serial.c
  group Drivers
    board/CubeMX_Config/Appli/Core/Src/: stm32h7rsxx_hal_msp.c
    board/: board.c drv_mpu.c
    board/port/: filesystem.c
    libraries/drivers/: drv_common.c drv_gpio.c drv_psram.c drv_spi.c drv_usart.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c cmd.c msh_file.c msh.c msh_parse.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    rt-thread/libcpu/arm/common/: div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group STM32_HAL
    libraries/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/: system_stm32h7rsxx.c
    libraries/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_cryp.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal.c stm32h7rsxx_hal_crc_ex.c stm32h7rsxx_hal_rng.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_adc.c stm32h7rsxx_hal_cryp_ex.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_cec.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_usart.c stm32h7rsxx_hal_adc_ex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_crc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_sram.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_xspi.c
    libraries/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/arm/: startup_stm32h7r7xx.s
